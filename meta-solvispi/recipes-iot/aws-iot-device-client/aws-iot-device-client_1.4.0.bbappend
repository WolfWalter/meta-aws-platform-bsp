PACKAGECONFIG += " samples"
PACKAGECONFIG += " pubsub"